# Keil uVision project Remote_Control.uvprojx, settings and files
target Remote_Control (5060960::V5.06 update 7 (build 960)::.\ARMCC5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Remote_Control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Common/config;../Common/debug;../Middleware/FreeRTOS;../Middleware/FreeRTOS/include;../Middleware/FreeRTOS/protable/ARM_CM3;../App/communication;../App/task;../Interface/2_4g;..\App\data_process;..\Interface\Joystick_Key;..\App\display;..\Interface\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Common
    ../Common/config/: Com_Config.c
    ../Common/debug/: Com_Debug.c
  group Middleware
    ../Middleware/FreeRTOS/: FreeRTOSConfig.h
    ../Middleware/FreeRTOS/protable/ARM_CM3/: port.c
    ../Middleware/FreeRTOS/protable/MemMang/: heap_4.c
    ../Middleware/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group App
    ../App/communication/: App_communication.c
    ../App/task/: App_Task.c
    ../App/data_process/: App_DataProcess.c
    ../App/display/: App_Display.c
  group Interface
    ../Interface/2_4g/: Inf_SI24R1.c
    ../Interface/Joystick_Key/: Inf_JoyStickAndKey.c
    ../Interface/oled/: oled.c oledfont.c
software components: CMSIS:CORE 4.3.0
