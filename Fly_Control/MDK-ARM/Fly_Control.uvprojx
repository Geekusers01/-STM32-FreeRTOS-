# Keil uVision project Fly_Control.uvprojx, settings and files
target Fly_Control (5060960::V5.06 update 7 (build 960)::.\ARMCC5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Fly_Control +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App/task;../Common/config;../Common/debug;../Interface/led;../Middleware/FreeRTOS;../Middleware/FreeRTOS/include;../Middleware/FreeRTOS/protable/ARM_CM3;../App/flight;../Interface/motor;../App/communication;../Interface/2_4g;../Interface/mpu;../Common/util;../Common/digital_scope;../Common/imu;../Common/pid;../Interface/i2c_soft;../Interface/vl53l1x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Common
    ../Common/config/: Com_Config.c
    ../Common/debug/: Com_Debug.c
    ../Common/util/: Com_Filter.c
    ../Common/imu/: Com_imu.c
    ../Common/pid/: Com_PID.c
    ../Common/digital_scope/: outputdata.c
  group Middleware
    ../Middleware/FreeRTOS/: FreeRTOSConfig.h
    ../Middleware/FreeRTOS/protable/ARM_CM3/: port.c
    ../Middleware/FreeRTOS/protable/MemMang/: heap_4.c
    ../Middleware/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group App
    ../App/task/: App_Task.c
    ../App/flight/: App_Flight.c
    ../App/communication/: App_communication.c
  group Interface
    ../Interface/led/: Inf_LED.c
    ../Interface/motor/: Inf_motor.c
    ../Interface/2_4g/: Inf_SI24R1.c
    ../Interface/mpu/: Inf_mpu6050.c
    ../Interface/i2c_soft/: Myi2c.c
    ../Interface/vl53l1x/: Inf_vl53l1x.c vl53l1_platform.c VL53L1X_api.c VL53L1X_calibration.c
software components: CMSIS:CORE 6.1.0
